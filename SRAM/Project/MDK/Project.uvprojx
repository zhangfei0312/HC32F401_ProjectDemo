# Keil uVision project Project.uvprojx, settings and files
target HC401B (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F401BRCX Holychip
  pack: Holychip.HC32F4XX.1.0.6
  cpu: IRAM(0x20000000,0x00030000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: VECT_TAB_SRAM
  c misc: --c99
  c include: ..\..\User;..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\Libraries\CMSIS\startup;..\..\User\bsp;..\..\User\src;..\..\User\inc;..\..\User\coremark
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  scatter file: ..\..\Output\Project.sct
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_hc32f40_41xxx.s
  group CMSIS
    ../../Libraries/CMSIS/: hc32f4xx.h system_hc32f4xx.c system_hc32f4xx.h core_sc300.h
  group FWLB
    ../../Libraries/FWlib/src/: hc32f4xx_adc.c hc32f4xx_canfd.c hc32f4xx_crc.c hc32f4xx_dac.c hc32f4xx_dbgmcu.c hc32f4xx_dma.c hc32f4xx_exti.c hc32f4xx_fda.c hc32f4xx_flash.c hc32f4xx_gpio.c hc32f4xx_i2c.c hc32f4xx_i2s.c hc32f4xx_iwdg.c hc32f4xx_mou.c hc32f4xx_pwr.c hc32f4xx_rcc.c hc32f4xx_rtc.c hc32f4xx_spi.c hc32f4xx_syscfg.c hc32f4xx_tim.c hc32f4xx_tim10.c hc32f4xx_usart.c hc32f4xx_vc.c hc32f4xx_wwdg.c misc.c
  group USER
    ../../User/: hc32f4xx_it.c hc32f4xx_it.h
  group BSP
    ../../User/src/: bsp_uart.c bsp_printf.c
  group Coremark
    ../../User/coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c core_portme.h
  group Doc
    ../../: Readme.txt
